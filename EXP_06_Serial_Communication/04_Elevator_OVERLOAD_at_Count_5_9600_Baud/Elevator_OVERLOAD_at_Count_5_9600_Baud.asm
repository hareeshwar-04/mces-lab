ORG 00H
MOV TMOD, #20H
MOV SCON, #50H
MOV TH1, #253
SETB TR1
MOV R0, #05H
COUNT: DJNZ R0, COUNT
MOV A, #'O'
ACALL TRANS
MOV A, #'V'
ACALL TRANS
MOV A, #'E'
ACALL TRANS
MOV A, #'R'
ACALL TRANS
MOV A, #'L'
ACALL TRANS
MOV A, #'O'
ACALL TRANS
MOV A, #'A'
ACALL TRANS
MOV A, #'D'
ACALL TRANS
HERE: SJMP HERE

TRANS: MOV SBUF, A
WAIT: JNB TI, WAIT
CLR TI
RET
END
