ORG 00H
MOV R0, #36H
MOV R1, #94H
MOV R2, #78H
MOV R3, #56H

MOV A, R0
MOV B, R2
MUL AB
MOV 53H, A
MOV R7, B

MOV A, R0
MOV B, R3
MUL AB
ADD A, R7
MOV R7, A
MOV R6, B

MOV A, R1
MOV B, R2
MUL AB
ADD A, R7
MOV 52H, A
MOV A, B
ADDC A, R6
MOV R6, A

MOV A, R1
MOV B, R3
MUL AB
ADD A, R6
MOV 51H, A
MOV A, B
ADDC A, #00H
MOV 50H, A
END
