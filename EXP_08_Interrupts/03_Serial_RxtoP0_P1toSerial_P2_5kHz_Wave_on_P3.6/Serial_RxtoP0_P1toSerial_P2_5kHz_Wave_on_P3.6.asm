ORG 00H
LJMP MAIN

ORG 000BH
CPL P3.6
RETI

ORG 0023H
JB TI, EVL
MOV P0, A
CLR RI
EVL: CLR TI
RETI

ORG 40H
MAIN: MOV IE, #92H
MOV TMOD, #22H
MOV SCON, #50H
MOV TH1, #250
MOV TH0, #0A4H
SETB P3.6
SETB TR0
SETB TR1
BACK: MOV A, P1
MOV SBUF, A
MOV P2, A
SJMP BACK
END
