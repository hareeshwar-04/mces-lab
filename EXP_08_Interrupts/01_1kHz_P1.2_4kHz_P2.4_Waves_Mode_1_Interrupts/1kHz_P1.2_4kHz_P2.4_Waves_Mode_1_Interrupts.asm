ORG 00H
LJMP MAIN

ORG 000BH
CPL P1.2
MOV TL0, #33H
MOV TH0, #0FEH
RETI

ORG 001BH
CPL P2.4
MOV TL1, #0CDH
MOV TH1, #0F8H
RETI

ORG 40H
MAIN: MOV IE, #8AH
MOV TMOD, #11H
MOV TL0, #33H
MOV TH0, #0FEH
MOV TL1, #0CDH
MOV TH1, #0F8H
SETB P1.2
SETB P2.4
SETB TR1
SETB TR0
HERE: SJMP HERE
END
